# IAR project CmBacktrace.ewp, settings and files
configuration stm32f103xE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RE ST STM32F103RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\app\inc; ..\components\others; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS_EWARM\Include; ..\Libraries\CMSIS_EWARM\CM3\DeviceSupport\ST\STM32F10x; ..\FreeRTOS; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM3; ..\components\cm_backtrace; ..\..\..\..\..\cm_backtrace
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\FreeRTOS
  OBJCOPY.OOCOutputFile: CmBacktrace.bin
  ILINK.IlinkOutputFile: CmBacktrace.out
  ILINK.IlinkIcfFile: ..\components\others\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/src/: app.c fault_test.c stm32f10x_it.c
  group components/cm_backtrace
    ../../../../../cm_backtrace/: cm_backtrace.c
    ../../../../../cm_backtrace/fault_handler/iar/: cmb_fault.S
  group components/others
    ../components/others/: bsp.c
  group freertos
    ../FreeRTOS/: FreeRTOSConfig.h list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group libs/cmsis
    ../Libraries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libs/std_periph_driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
